SUMMARY:${PN} = "Intel Package Group"

inherit packagegroup

RDEPENDS:${PN} = " \
        cups \
        node-manager \
        "