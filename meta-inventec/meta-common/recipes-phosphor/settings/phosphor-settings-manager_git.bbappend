FILESEXTRAPATHS:append := ":${THISDIR}/${PN}"
SRC_URI:append = " file://sol-parameters.override.yml \
                 "
