SYSTEMD_SERVICE:${PN} += "xyz.openbmc_project.mctpd@smbus.service"
SYSTEMD_SERVICE:${PN} += "xyz.openbmc_project.mctpd@pcie.service"
