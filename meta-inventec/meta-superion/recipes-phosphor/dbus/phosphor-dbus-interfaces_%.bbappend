FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-copy-yaml-and-add-to-xyz.patch "
