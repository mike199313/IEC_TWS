FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
            file://0001-Support-OOB-PFR-secure-update.patch \
           "
