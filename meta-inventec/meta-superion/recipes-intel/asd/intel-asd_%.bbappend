FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"

SRC_URI += " file://0001-Set-unuse-gpios-to-PIN_NONE.patch \
           "